ORGANIZATION_BLOCK OB 1
BEGIN
	// Test SFC -1: __NOP
	CALL		SFC -1
END_ORGANIZATION_BLOCK
